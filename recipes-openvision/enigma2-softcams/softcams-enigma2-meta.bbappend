DEPENDS_remove_dm800 = "\
	enigma2-plugin-softcams-rqcamd \
	"
