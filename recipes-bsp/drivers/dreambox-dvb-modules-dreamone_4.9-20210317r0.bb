SRC_URI[dreamone.md5sum] = "14f2e4c4a641b8686d6fe7cae90d7d32"
SRC_URI[dreamone.sha256sum] = "f713146fb32caca2de129d3dca9d9d94a693c907359b972f060b28fb28a1a8f7"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamone)$"
