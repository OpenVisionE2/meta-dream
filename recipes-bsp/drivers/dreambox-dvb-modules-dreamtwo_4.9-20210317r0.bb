SRC_URI[dreamtwo.md5sum] = "d81f60143a5bef7c092f9aa5b2f8e13f"
SRC_URI[dreamtwo.sha256sum] = "5696710cf32b44ceec5c537b0455fd9b5652b90cf611f39670e68de403bf71d3"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
