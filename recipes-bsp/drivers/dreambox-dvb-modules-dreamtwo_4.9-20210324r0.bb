SRC_URI[dreamtwo.md5sum] = "dac11417256cdcb6d10d024b77a86322"
SRC_URI[dreamtwo.sha256sum] = "613a2a2c006f2bcd19fc761a703a208de03ddaf27517a766d195e27f7642d9f2"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
