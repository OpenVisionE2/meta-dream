SRC_URI[dreamone.md5sum] = "77f91d3aa912405b45db5bb744b08277"
SRC_URI[dreamone.sha256sum] = "a0fbd1958f1149e367f55a9d357a41ace6c514844e4b0b9758c3e9f65351e66a"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamone)$"
