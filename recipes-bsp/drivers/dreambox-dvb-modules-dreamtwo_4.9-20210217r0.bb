SRC_URI[dreamtwo.md5sum] = "77f3ba3815a507466c10153f8fd45ef5"
SRC_URI[dreamtwo.sha256sum] = "228eb66ea016697539b40a67b60a348f275e4b384e3f50118f3723bf6f121cbe"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
