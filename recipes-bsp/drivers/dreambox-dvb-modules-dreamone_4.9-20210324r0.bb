SRC_URI[dreamone.md5sum] = "c8565886e248a5a0d4bbda2aeaa9b507"
SRC_URI[dreamone.sha256sum] = "a292685e14a9f62d6f73b230b79bf3fbe8ccca0a820c1d370c5a3cdd14fb6e4a"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamone)$"
